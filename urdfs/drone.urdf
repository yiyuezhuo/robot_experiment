Commit message: complete tank_vs_bandit scenario

File: urdfs/drone.urdf (robot description, URDF)
Before this commit: robot drone, 9 links, 8 joints
Joints:
- joint p2: axis 0 0 1 -> 0 0 -1
- joint p3: axis 0 0 1 -> 0 0 -1
